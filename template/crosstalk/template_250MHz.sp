******************** STL ver 2.3 250MHz clock crosstalk model ********************

*** Notice *** ------------------------------------------------------*
* 関（2014年度卒）が卒論及びEDAPS2012で用いた，クロストーク系の 250MHz クロック入力，400mm，無損失伝送線モデルのテンプレート
* 関 が卒業研究で使ったのは STLデザイナー1 でしたが，卒論及び残っていたファイルを参考に STLデザイナー2 用のテンプレートを作成しました．
* WモデルのRLGCの値は島田さん（2013年度卒）が用いていた差動インピーダンスをそのまま利用しています．

*--------------------------------------------------------------------*

*** STL Circuit *** -------------------------------------------------*

Vs1             101     0       PWL(
.INCLUDE ./data/input_data/250MHz_81132A_2V_20pulse )
Rin1            101     102     50
Rin2            0       202     50

W1_STL_4        102     202     0       103     203     0       RLGCMODEL=Z100  N=2     L=50m
W2_STL_5        103     203     0       104     204     0       RLGCMODEL=Z100  N=2     L=300m
W3_STL_7        104     204     0       optpt1  optpt2  0       RLGCMODEL=Z100  N=2     L=50m

RT1             optpt1  0       50
RT2             optpt2  0       50

*--------------------------------------------------------------------*

*** Versus Circuit *** ----------------------------------------------*

*** Versus TL 1 ***
Vs1001          1001    0       PWL(
.INCLUDE ./data/input_data/250MHz_81132A_2V_20pulse )
Rin1001         1001    1002    50
T1001           1002    0       vspt1   0       z0=50   TD=2523.2p
RT1001          vspt1   0       50

*** Versus TL 2 ***
T2001           0       0       vspt2   0       z0=50   TD=2523.2p

*--------------------------------------------------------------------*

*** Trigger Circuit *** ---------------------------------------------*

*--------------------------------------------------------------------*

*** Netlist Commands *** --------------------------------------------*

* プリントアウト幅（80 or 132）
.WIDTH OUT=132
.TRAN 5p 53n 40n
.PRINT v(optpt1) v(optpt2) v(vspt1) v(vspt2)

* 先輩（島田さん，2013年度卒）から引き継いだデータをコピペしたもので，RLGCモデルは差動インピーダンスを元に命名されています．
* 例えば，Z100 は差動インピーダンス100ohmの時のRLGCモデルなので，Z100の時が特性インピーダンス50ohmに近い値です．
* 本来は特性インピーダンスで考えるべきですが，先行研究（島田さん）が差動でそのまま引き継いで始めたため，誤って差動インピーダンスを元にしています．
* 配線間隔は一律 0.4mm で，配線幅を各モデルの先頭行にコメントしてあります．（参考：./document/RLGC差動new_250MHz.xlsx）
*---------------------------------
* 配線幅：0.137 mm
.MODEL Z160 W ModelType=RLGC N=2
+ Lo=
+ 699.081955e-9
+ 234.9237197e-9 699.081955e-9
+ Co=
+ 48.62616188e-12
+ -12.43798062e-12 48.62616188e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.162 mm
.MODEL Z155 W ModelType=RLGC N=2
+ Lo=
+ 674.0763419e-9
+ 227.3538051e-9 674.0763419e-9
+ Co=
+ 50.86707661e-12
+ -13.03497309e-12 50.86707661e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.190 mm
.MODEL Z150 W ModelType=RLGC N=2
+ Lo=
+ 649.5554895e-9
+ 219.4072421e-9 649.5554895e-9
+ Co=
+ 53.20759296e-12
+ -13.61173739e-12 53.20759296e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.221 mm
.MODEL Z145 W ModelType=RLGC N=2
+ Lo=
+ 625.6108916e-9
+ 211.1935101e-9 625.6108916e-9
+ Co=
+ 55.64523287e-12
+ -14.16375633e-12 55.64523287e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.257 mm
.MODEL Z140 W ModelType=RLGC N=2
+ Lo=
+ 600.9396681e-9
+ 202.3357611e-9 600.9396681e-9
+ Co=
+ 58.33001629e-12
+ -14.71939479e-12 58.33001629e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.298 mm
.MODEL Z135 W ModelType=RLGC N=2
+ Lo=
+ 576.2270089e-9
+ 193.0419244e-9 576.2270089e-9
+ Co=
+ 61.22897282e-12
+ -15.25736298e-12 61.22897282e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.344 mm
.MODEL Z130 W ModelType=RLGC N=2
+ Lo=
+ 551.8448852e-9
+ 183.494919e-9 551.8448852e-9
+ Co=
+ 64.32813992e-12
+ -15.76670025e-12 64.32813992e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.396 mm
.MODEL Z125 W ModelType=RLGC N=2
+ Lo=
+ 527.6111229e-9
+ 173.6736472e-9 527.6111229e-9
+ Co=
+ 67.68388077e-12
+ -16.24920592e-12 67.68388077e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.456 mm
.MODEL Z120 W ModelType=RLGC N=2
+ Lo=
+ 502.8142402e-9
+ 163.4470849e-9 502.8142402e-9
+ Co=
+ 71.43581468e-12
+ -16.72521961e-12 71.43581468e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.523 mm
.MODEL Z115 W ModelType=RLGC N=2
+ Lo=
+ 478.3105326e-9
+ 153.223244e-9 478.3105326e-9
+ Co=
+ 75.51233733e-12
+ -17.17916683e-12 75.51233733e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.599 mm
.MODEL Z110 W ModelType=RLGC N=2
+ Lo=
+ 453.9097384e-9
+ 142.9094864e-9 453.9097384e-9
+ Co=
+ 80.01365219e-12
+ -17.61106412e-12 80.01365219e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.686 mm
.MODEL Z105 W ModelType=RLGC N=2
+ Lo=
+ 429.4630811e-9
+ 132.5003768e-9 429.4630811e-9
+ Co=
+ 85.04979198e-12
+ -18.02564478e-12 85.04979198e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.784 mm
.MODEL Z100 W ModelType=RLGC N=2
+ Lo=
+ 405.4312101e-9
+ 122.2493932e-9 405.4312101e-9
+ Co=
+ 90.61540222e-12
+ -18.41881175e-12 90.61540222e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：0.897 mm
.MODEL Z95 W ModelType=RLGC N=2
+ Lo=
+ 381.3393735e-9
+ 112.0088756e-9 381.3393735e-9
+ Co=
+ 96.93034649e-12
+ -18.80112454e-12 96.93034649e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：1.025 mm
.MODEL Z90 W ModelType=RLGC N=2
+ Lo=
+ 357.7161044e-9
+ 102.0533384e-9 357.7161044e-9
+ Co=
+ 103.9900613e-12
+ -19.16900886e-12 103.9900613e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：1.171 mm
.MODEL Z85 W ModelType=RLGC N=2
+ Lo=
+ 334.4813644e-9
+ 92.39084836e-9 334.4813644e-9
+ Co=
+ 111.9610348e-12
+ -19.53185626e-12 111.9610348e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：1.339 mm
.MODEL Z80 W ModelType=RLGC N=2
+ Lo=
+ 311.5477854e-9
+ 83.02164815e-9 311.5477854e-9
+ Co=
+ 121.0590949e-12
+ -19.89734977e-12 121.0590949e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：1.534 mm
.MODEL Z75 W ModelType=RLGC N=2
+ Lo=
+ 288.8661461e-9
+ 73.95863203e-9 288.8661461e-9
+ Co=
+ 131.5512142e-12
+ -20.27229062e-12 131.5512142e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：1.761 mm
.MODEL Z70 W ModelType=RLGC N=2
+ Lo=
+ 268.1966148e-9
+ 65.04328502e-9 268.1966148e-9
+ Co=
+ 142.980614e-12
+ -20.26146521e-12 142.980614e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：2.027 mm
.MODEL Z65 W ModelType=RLGC N=2
+ Lo=
+ 246.4151681e-9
+ 56.8163238e-9 246.4151681e-9
+ Co=
+ 157.0447755e-12
+ -20.61128002e-12 157.0447755e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------
* 配線幅：2.343 mm
.MODEL Z60 W ModelType=RLGC N=2
+ Lo=
+ 224.9087986e-9
+ 49.00822203e-9 224.9087986e-9
+ Co=
+ 173.7110658e-12
+ -20.98215459e-12 173.7110658e-12
+ Ro=
+ 0
+ 0 0
+ Go=
+ 0
+ 0 0

*---------------------------------

.END

*--------------------------------------------------------------------*
